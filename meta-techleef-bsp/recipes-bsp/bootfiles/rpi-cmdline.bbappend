# Root partition is selected dynamically by U-Boot for RAUC A/B.
CMDLINE_ROOTFS:techleef-rpi3w64 = "rootfstype=ext4 rootwait"
