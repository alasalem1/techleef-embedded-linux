FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://optimize.cfg file://0001-add-techleef-hcsr04-overlay.patch"
