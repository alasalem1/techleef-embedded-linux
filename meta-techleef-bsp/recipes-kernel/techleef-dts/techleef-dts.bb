SUMMARY = "Techleef HCSR04 Device Tree overlay"
LICENSE = "CLOSED"